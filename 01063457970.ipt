# Autodesk Inventor part: 01063457970
## iProperties
Created: 2015-03
Part Number: 01063457970
Document SubType Name: Modeling
Designer: won t
Density: 1 g/cm^3
Author: won t
